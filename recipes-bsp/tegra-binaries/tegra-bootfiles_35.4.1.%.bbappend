PARTITION_FILE = "${S}/bootloader/${NVIDIA_BOARD}/cfg/flash_t234_qspi_sdmmc_custom.xml"
